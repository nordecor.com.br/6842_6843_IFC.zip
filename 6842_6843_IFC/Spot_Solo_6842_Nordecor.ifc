Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-10-10T17:10:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Oct 10 17:10:45 2025 * Host: MichellyManno * Database: C:\Users\miche\AppData\Local\Temp\cd24c564-bd14-4532-8675-4bdfa3a8a21c\925d3046-7dac-4258-b38a-156b5c9e59d6\ifc * Database version: 5507 * Database creation date: Fri Oct 10 17:10:45 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Oct 10 17:10:45 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Oct 10 17:10:45 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcDistributionPort, Port_328231
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: 6842, Spot_Solo_6842_6843_Nordecor_IFC:6842:328231
In: Nível 1
Type - Material: LED, Plástico - Policarbonato - Translúcido, Metal - Alumínio - Preto, Metal - Aço inox - Cinza
Type - Cotas - Altura da luminária: 75 mm; Diâmetro da luminária: 65 mm; Diâmetro do nicho: 62 mm
Type - Dados - Data de atualização: 10/10/2025; Versão: 1
Type - Dados de identidade - Código Uniformat: D5020.20; Comentários de tipos: spot de solo, embutir, LED, 5W, 2700K, facho fechado 12º, iluminação externa, paisagismo, fachada; Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Spot de embutir no solo SENF com acabamento preto, LED 5W, 2700K 12º; Descrição UniFormat: Luminárias integradas ao edifício; Desenvolvedor: Check BIM; Fabricante: Nordecor; Garantia: 2 Anos; Grau de proteção: IP67; Localização: Camboriú-SC / Brasil; Modelo: 6842; Nome do tipo: 6842; Nota-chave: 26 56 36.23; Número MasterFormat: 26 56 36; Número OmniClass: 23.80.70.11.14.14; Tipo de fixação: Embutido no solo; Tipo de imagem: Imagem raster: 6842.png; Tipo de luminária: Distribuição Direcional / Facho Concentrado; Título MasterFormat: Luminárias de Paisagismo; Título OmniClass: Uplights; URL: https://nordecor.com.br; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/spot-led-para-solo-senf-12o-5w-2-700k-irc90/
Type - Elétrico - Comentários de voltagem: 85-265V; Fator de potência - Luminária: 1; Lâmpada: LED
Type - Elétrico - Cargas - Carga aparente - Luminária: 0 W
Type - Engenharia elétrica - Voltagem - Luminária: 0 V
Type - Estrutural - Peso da luminária: 0
Type - Fotométricos - Fluxo luminoso: 483 lm; Grau de abertura: 12 deg; IRC: >90; Potência: 5 W; Temperatura da cor: 2700 K
Type - Materiais e acabamentos - Borda: Metal - Aço inox - Cinza; Difusor: Plástico - Policarbonato - Translúcido; Luminária: Metal - Alumínio - Preto
Type - Outros - Categoria: Luminárias; Alumínio: yes; Nome da família: Spot_Solo_6842_6843_Nordecor_IFC; Preto: no
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes
Pset_DistributionFlowElementCommon - Reference: 6842; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Nordecor
Cotas - Área: 0.0113173 m2; Volume: 0.000121883 m3
Dados de identidade - Marca: 1
Elétrico - Circuitos - Dados elétricos: 0 V/1-0 VA
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Família: Spot_Solo_6842_6843_Nordecor_IFC: 6842; Família e tipo: Spot_Solo_6842_6843_Nordecor_IFC: 6842; ID de tipo: Spot_Solo_6842_6843_Nordecor_IFC: 6842; Tipo: Spot_Solo_6842_6843_Nordecor_IFC: 6842
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
